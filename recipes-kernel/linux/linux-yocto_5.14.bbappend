
COMPATIBLE_MACHINE = "odroid-u3"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://defconfig"
#SRC_URI += "file://.config"
